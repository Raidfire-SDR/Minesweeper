options:
  parameters:
    author: raidfire
    generate_options: no_gui
    id: xml_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: gainl
  id: variable_qtgui_label
  parameters:
    type: int
    value: gainp
  states: {state: disabled}
- name: lol
  id: variable_qtgui_label
  parameters:
    type: real
    value: lop
  states: {state: disabled}
- name: rfl
  id: variable_qtgui_label
  parameters:
    type: int
    value: rfp
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: test
  id: variable_qtgui_label
  parameters:
    type: string
    value: testp
  states: {state: disabled}
- name: threshl
  id: variable_qtgui_label
  parameters:
    type: int
    value: threshp
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0.01'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshp
    init: '0'
    low: '10'
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: f1p
  id: parameter
  parameters:
    type: eng_float
    value: '131001'
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '8'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: gainp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lop
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lop
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: lop
  id: parameter
  parameters:
    type: intx
    value: '4200000000'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6004'
    type: complex
  states: {}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6003'
    type: complex
  states: {}
- name: network_tcp_sink_2
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6002'
    type: float
  states: {}
- name: network_tcp_sink_3
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6001'
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: samp_rate
    freq0: lop
    gain0: '90'
    if_gain0: '20'
    maxoutbuf: '10000000'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: rfp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: lop
    gain0: gainp
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: testp
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: threshp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '6005'
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '6006'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_agc_xx_0, '0', network_tcp_sink_0, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_agc_xx_0_0, '0', network_tcp_sink_1, '0']
- [analog_sig_source_x_0_0, '0', analog_agc_xx_0, '0']
- [analog_sig_source_x_0_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0_0, '0', iio_pluto_sink_1, '0']
- [analog_sig_source_x_0_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_threshold_ff_0, '0', network_tcp_sink_2, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_vector_to_stream_0_0, '0', network_tcp_sink_3, '0']
- [fft_vxx_0_0_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [rtlsdr_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
