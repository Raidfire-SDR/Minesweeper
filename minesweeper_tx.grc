options:
  parameters:
    author: raidfire
    generate_options: no_gui
    id: radar_rx
    output_language: python
    title: Radar Rx
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: gainl
  id: variable_qtgui_label
  parameters:
    type: int
    value: gainp
  states: {state: disabled}
- name: lol
  id: variable_qtgui_label
  parameters:
    type: real
    value: lop
  states: {state: disabled}
- name: rfl
  id: variable_qtgui_label
  parameters:
    type: int
    value: rfp
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: "#!/usr/bin/env python3\r\n# -*- coding: utf-8 -*-\r\n\r\n#\r\n# SPDX-License-Identifier: GPL-3.0\r\n#\r\n# GNU Radio Python Flow Graph\r\n# Title: Not titled yet\r\n# Author: raidfire\r\n# GNU Radio version: 3.10.4.0\r\n\r\nfrom gnuradio import analog\r\nfrom gnuradio import blocks\r\nfrom gnuradio import fft\r\nfrom gnuradio.fft import window\r\nfrom gnuradio import gr\r\nfrom gnuradio.filter import firdes\r\nimport sys\r\nimport signal\r\nfrom argparse import ArgumentParser\r\nfrom gnuradio.eng_arg import eng_float, intx\r\nfrom gnuradio import eng_notation\r\nfrom gnuradio import iio\r\nfrom gnuradio import network\r\nfrom xmlrpc.server import SimpleXMLRPCServer\r\nimport threading\r\n\r\n\r\n\r\n\r\nclass xml_test(gr.top_block):\r\n\r\n    def __init__(self, f1p=131001, gainp=0, lop=4200000000, rfp=0, testp='0', threshp=0):\r\n        gr.top_block.__init__(self, \"Not titled yet\", catch_exceptions=True)\r\n\r\n        ##################################################\r\n        # Parameters\r\n        ##################################################\r\n        self.f1p = f1p\r\n        self.gainp = gainp\r\n        self.lop = lop\r\n        self.rfp = rfp\r\n        self.testp = testp\r\n        self.threshp = threshp\r\n\r\n        ##################################################\r\n        # Variables\r\n        ##################################################\r\n        self.samp_rate = samp_rate = 2000000\r\n        self.fft_size = fft_size = 512\r\n        self.decim = decim = 1024\r\n\r\n        ##################################################\r\n        # Blocks\r\n        ##################################################\r\n        self.xmlrpc_server_0 = SimpleXMLRPCServer(('127.0.0.1', 6005), allow_none=True)\r\n        self.xmlrpc_server_0.register_instance(self)\r\n        self.xmlrpc_server_0_thread = threading.Thread(target=self.xmlrpc_server_0.serve_forever)\r\n        self.xmlrpc_server_0_thread.daemon = True\r\n        self.xmlrpc_server_0_thread.start()\r\n        self.network_tcp_sink_3 = network.tcp_sink(gr.sizeof_float, 1, '127.0.0.1', 6001,2)\r\n        self.iio_pluto_source_0 = iio.fmcomms2_source_fc32('ip:192.168.2.1' if 'ip:192.168.2.1' else iio.get_pluto_uri(), [True, True], 32768)\r\n        self.iio_pluto_source_0.set_len_tag_key('packet_len')\r\n        self.iio_pluto_source_0.set_frequency(lop)\r\n        self.iio_pluto_source_0.set_samplerate(samp_rate)\r\n        self.iio_pluto_source_0.set_gain_mode(0, 'manual')\r\n        self.iio_pluto_source_0.set_gain(0, gainp)\r\n        self.iio_pluto_source_0.set_quadrature(True)\r\n        self.iio_pluto_source_0.set_rfdc(True)\r\n        self.iio_pluto_source_0.set_bbdc(True)\r\n        self.iio_pluto_source_0.set_filter_params('Auto', '', 0, 0)\r\n        self.iio_pluto_sink_1 = iio.fmcomms2_sink_fc32('ip:192.168.2.1' if 'ip:192.168.2.1' else iio.get_pluto_uri(), [True, True], 32768, False)\r\n        self.iio_pluto_sink_1.set_len_tag_key('')\r\n        self.iio_pluto_sink_1.set_bandwidth(20000000)\r\n        self.iio_pluto_sink_1.set_frequency(lop)\r\n        self.iio_pluto_sink_1.set_samplerate(samp_rate)\r\n        self.iio_pluto_sink_1.set_attenuation(0, 0)\r\n        self.iio_pluto_sink_1.set_filter_params('Auto', '', 0, 0)\r\n        self.fft_vxx_0_0_0_1 = fft.fft_vcc(fft_size, True, window.blackmanharris(fft_size), False, 8)\r\n        self.blocks_vector_to_stream_0_0 = blocks.vector_to_stream(gr.sizeof_float*1, fft_size)\r\n        self.blocks_throttle_0 = blocks.throttle(gr.sizeof_float*1, samp_rate,True)\r\n        self.blocks_stream_to_vector_0_1 = blocks.stream_to_vector(gr.sizeof_gr_complex*1, fft_size)\r\n        self.blocks_multiply_conjugate_cc_0 = blocks.multiply_conjugate_cc(1)\r\n        self.blocks_complex_to_mag_0_0 = blocks.complex_to_mag(fft_size)\r\n        self.analog_sig_source_x_0_0 = analog.sig_source_c(samp_rate, analog.GR_COS_WAVE, 10000, 1, 0.01, 0)\r\n        self.analog_agc_xx_0_0 = analog.agc_cc((1e-4), 1.0, 1.0)\r\n        self.analog_agc_xx_0_0.set_max_gain(65536)\r\n        self.analog_agc_xx_0 = analog.agc_cc((1e-4), 1.0, 1.0)\r\n        self.analog_agc_xx_0.set_max_gain(65536)\r\n\r\n\r\n        ##################################################\r\n        # Connections\r\n        ##################################################\r\n        self.connect((self.analog_agc_xx_0, 0), (self.blocks_multiply_conjugate_cc_0, 0))\r\n        self.connect((self.analog_agc_xx_0_0, 0), (self.blocks_multiply_conjugate_cc_0, 1))\r\n        self.connect((self.analog_sig_source_x_0_0, 0), (self.analog_agc_xx_0, 0))\r\n        self.connect((self.analog_sig_source_x_0_0, 0), (self.iio_pluto_sink_1, 0))\r\n        self.connect((self.blocks_complex_to_mag_0_0, 0), (self.blocks_vector_to_stream_0_0, 0))\r\n        self.connect((self.blocks_multiply_conjugate_cc_0, 0), (self.blocks_stream_to_vector_0_1, 0))\r\n        self.connect((self.blocks_stream_to_vector_0_1, 0), (self.fft_vxx_0_0_0_1, 0))\r\n        self.connect((self.blocks_throttle_0, 0), (self.network_tcp_sink_3, 0))\r\n        self.connect((self.blocks_vector_to_stream_0_0, 0), (self.blocks_throttle_0, 0))\r\n        self.connect((self.fft_vxx_0_0_0_1, 0), (self.blocks_complex_to_mag_0_0, 0))\r\n        self.connect((self.iio_pluto_source_0, 0), (self.analog_agc_xx_0_0, 0))\r\n\r\n\r\n    def get_f1p(self):\r\n        return self.f1p\r\n\r\n    def set_f1p(self, f1p):\r\n        self.f1p = f1p\r\n\r\n    def get_gainp(self):\r\n        return self.gainp\r\n\r\n    def set_gainp(self, gainp):\r\n        self.gainp = gainp\r\n        self.iio_pluto_source_0.set_gain(0, self.gainp)\r\n\r\n    def get_lop(self):\r\n        return self.lop\r\n\r\n    def set_lop(self, lop):\r\n        self.lop = lop\r\n        self.iio_pluto_sink_1.set_frequency(self.lop)\r\n        self.iio_pluto_source_0.set_frequency(self.lop)\r\n\r\n    def get_rfp(self):\r\n        return self.rfp\r\n\r\n    def set_rfp(self, rfp):\r\n        self.rfp = rfp\r\n\r\n    def get_testp(self):\r\n        return self.testp\r\n\r\n    def set_testp(self, testp):\r\n        self.testp = testp\r\n\r\n    def get_threshp(self):\r\n        return self.threshp\r\n\r\n    def set_threshp(self, threshp):\r\n        self.threshp = threshp\r\n\r\n    def get_samp_rate(self):\r\n        return self.samp_rate\r\n\r\n    def set_samp_rate(self, samp_rate):\r\n        self.samp_rate = samp_rate\r\n        self.analog_sig_source_x_0_0.set_sampling_freq(self.samp_rate)\r\n        self.blocks_throttle_0.set_sample_rate(self.samp_rate)\r\n        self.iio_pluto_sink_1.set_samplerate(self.samp_rate)\r\n        self.iio_pluto_source_0.set_samplerate(self.samp_rate)\r\n\r\n    def get_fft_size(self):\r\n        return self.fft_size\r\n\r\n    def set_fft_size(self, fft_size):\r\n        self.fft_size = fft_size\r\n\r\n    def get_decim(self):\r\n        return self.decim\r\n\r\n    def set_decim(self, decim):\r\n        self.decim = decim\r\n\r\n\r\n\r\ndef argument_parser():\r\n    parser = ArgumentParser()\r\n    parser.add_argument(\r\n        \"--f1p\", dest=\"f1p\", type=eng_float, default=eng_notation.num_to_str(float(131001)),\r\n        help=\"Set f1p [default=%(default)r]\")\r\n    parser.add_argument(\r\n        \"--gainp\", dest=\"gainp\", type=intx, default=0,\r\n        help=\"Set gainp [default=%(default)r]\")\r\n    parser.add_argument(\r\n        \"--lop\", dest=\"lop\", type=intx, default=4200000000,\r\n        help=\"Set lop [default=%(default)r]\")\r\n    parser.add_argument(\r\n        \"--rfp\", dest=\"rfp\", type=intx, default=0,\r\n        help=\"Set rfp [default=%(default)r]\")\r\n    parser.add_argument(\r\n        \"--testp\", dest=\"testp\", type=str, default='0',\r\n        help=\"Set testp [default=%(default)r]\")\r\n    parser.add_argument(\r\n        \"--threshp\", dest=\"threshp\", type=intx, default=0,\r\n        help=\"Set threshp [default=%(default)r]\")\r\n    return parser\r\n\r\n\r\ndef main(top_block_cls=xml_test, options=None):\r\n    if options is None:\r\n        options = argument_parser().parse_args()\r\n    tb = top_block_cls(f1p=options.f1p, gainp=options.gainp, lop=options.lop, rfp=options.rfp, testp=options.testp, threshp=options.threshp)\r\n\r\n    def sig_handler(sig=None, frame=None):\r\n        tb.stop()\r\n        tb.wait()\r\n\r\n        sys.exit(0)\r\n\r\n    signal.signal(signal.SIGINT, sig_handler)\r\n    signal.signal(signal.SIGTERM, sig_handler)\r\n\r\n    tb.start()\r\n\r\n    try:\r\n        input('Press Enter to quit: ')\r\n    except EOFError:\r\n        pass\r\n    tb.stop()\r\n    tb.wait()\r\n\r\n\r\nif __name__ == '__main__':\r\n    main()"
  states: {state: disabled}
- name: test
  id: variable_qtgui_label
  parameters:
    type: string
    value: testp
  states: {state: disabled}
- name: threshl
  id: variable_qtgui_label
  parameters:
    type: int
    value: threshp
  states: {state: disabled}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: int
    value: threshp
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0.01'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshp
    init: '0'
    low: '10'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      from gnuradio import gr
      import numpy as np
      from PyQt5 import Qt
      from gnuradio import eng_notation
      from gnuradio import qtgui
      from gnuradio.filter import firdes
      import sip
      from gnuradio import analog

      from gnuradio.fft import window
      import sys
      import signal
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from xmlrpc.client import ServerProxy
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, freq='Initialising'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Trigger Test2',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.freq = freq

              self.xmlrpc_client_0 = ServerProxy('http://'+'localhost'+':8080')    

          def get_freq(self):
              return self.freq

          def set_freq(self, freq):
              self.freq = freq

          def work(self, input_items, output_items):

              output_items[0][:]=input_items[0]
              var=(output_items[0])
              state0 ='No Target Detected'
              state1= 'Target Detected'
              state=''
              if(any(var)==True):
                  state=state1
                  self.freq=state1
                 # playsound.playsound('1.mp3')
              if(any(var)==False):
                  state=state0
                  self.freq=state0
                  #pysine.sine(frequency=440.0, duration=1.0)
              self.xmlrpc_client_0.set_freq(self.freq)
              return len(input_items[0])
    freq: '1.0'
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport RPi.GPIO as GPIO\nGPIO.setmode(GPIO.BOARD)\nGPIO.setup(12, GPIO.OUT)\n\nGPIO.output(18, 1)\n\n"
  states: {}
- name: f1p
  id: parameter
  parameters:
    type: eng_float
    value: '131001'
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '8'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: gainp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lop
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lop
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: lop
    gain1: '''manual'''
    manual_gain1: gainp
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: lop
  id: parameter
  parameters:
    type: intx
    value: '4200000000'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6004'
    type: complex
  states: {}
- name: network_tcp_sink_1
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6003'
    type: complex
  states: {}
- name: network_tcp_sink_2
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6001'
    type: float
  states: {}
- name: network_tcp_sink_3
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6002'
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: samp_rate
    freq0: lop
    gain0: '90'
    if_gain0: '20'
    maxoutbuf: '10000000'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: rfp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: str(grgsm.device.get_default_args(args))
    bb_gain0: '20'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: lop
    gain0: gainp
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '1000000'
  states: {}
- name: testp
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: threshp
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 192.168.1.104
    port: '6005'
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: 192.168.1.103
    port: '6006'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_agc_xx_0, '0', network_tcp_sink_0, '0']
- [analog_agc_xx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_agc_xx_0_0, '0', network_tcp_sink_1, '0']
- [analog_sig_source_x_0_0, '0', analog_agc_xx_0, '0']
- [analog_sig_source_x_0_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0_0, '0', iio_pluto_sink_1, '0']
- [analog_sig_source_x_0_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_2_0, '0']
- [blocks_threshold_ff_0, '0', network_tcp_sink_2, '0']
- [blocks_throttle_0, '0', network_tcp_sink_3, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_throttle_0, '0']
- [epy_block_2_0, '0', blocks_null_sink_0, '0']
- [fft_vxx_0_0_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0_0, '0']
- [rtlsdr_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
