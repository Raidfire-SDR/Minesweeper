options:
  parameters:
    author: raidfire
    generate_options: qt_gui
    id: xml_client_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '1024'
  states: {state: disabled}
- name: f1p
  id: variable
  parameters:
    value: f1r
  states: {state: disabled}
- name: f1r
  id: variable_qtgui_range
  parameters:
    label: Modulatrion Frequency
    outputmsgname: value
    showports: 'False'
    start: '1'
    step: '1000'
    stop: '10000000'
    value: '10000'
  states: {state: disabled}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {state: disabled}
- name: gainp
  id: variable
  parameters:
    value: gainr
  states: {state: disabled}
- name: gainr
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '79'
    value: '50'
  states: {state: disabled}
- name: lop
  id: variable
  parameters:
    value: lor
  states: {state: disabled}
- name: lor
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    min_len: '5900000000'
    outputmsgname: value
    showports: 'False'
    start: '5900000000'
    step: '1'
    stop: '5900000000'
    value: '5900000000'
  states: {state: disabled}
- name: rfr
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: threshp
  id: variable
  parameters:
    value: threshr
  states: {}
- name: threshr
  id: variable_qtgui_range
  parameters:
    label: Detection Threshold
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '1000'
    value: '175'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Detection Status
    type: string
    value: freq
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshp
    init: '0'
    low: '10'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_3
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      from gnuradio import gr
      import numpy as np
      from PyQt5 import Qt
      from gnuradio import eng_notation
      from gnuradio import qtgui
      from gnuradio.filter import firdes
      import sip
      from gnuradio import analog

      from gnuradio.fft import window
      import sys
      import signal
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from xmlrpc.client import ServerProxy
      import threading


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, freq='Initialising'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Trigger Test2',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.freq = freq

              self.xmlrpc_client_0 = ServerProxy('http://'+'localhost'+':8080')    

          def get_freq(self):
              return self.freq

          def set_freq(self, freq):
              self.freq = freq

          def work(self, input_items, output_items):

              output_items[0][:]=input_items[0]
              var=(output_items[0])
              state0 ='No Target Detected'
              state1= 'Target Detected'
              state=''
              if(any(var)==True):
                  state=state1
                  self.freq=state1
                 # playsound.playsound('1.mp3')
              if(any(var)==False):
                  state=state0
                  self.freq=state0
                  #pysine.sine(frequency=440.0, duration=1.0)
              self.xmlrpc_client_0.set_freq(self.freq)
              return len(input_items[0])
    freq: '1.0'
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '8'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    type: str
    value: Initialising
  states: {}
- name: ip
  id: parameter
  parameters:
    type: str
    value: 192.168.1.104
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: ip
    port: '6003'
    server: 'False'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: ip
    port: '6004'
    server: 'False'
    type: complex
  states: {state: disabled}
- name: network_tcp_source_2_0
  id: network_tcp_source
  parameters:
    addr: ip
    port: '6001'
    server: 'False'
    type: float
  states: {}
- name: network_tcp_source_2_0_0
  id: network_tcp_source
  parameters:
    addr: ip
    port: '6002'
    server: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Diff
    max: '5000'
    min: '0'
    name: '"Reflection difference"'
    type: float
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Detect
    min: '0'
    name: '"STATE"'
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: '256'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label3: RX
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style2: '0'
    style4: '0'
    type: complex
    width3: '0'
    width4: '0'
  states: {state: disabled}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_rfp
    port: '6005'
    variable: rfp
  states: {state: disabled}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_lop
    port: '6005'
    variable: lop
  states: {state: disabled}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_gainp
    port: '6005'
    variable: gainp
  states: {state: disabled}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: ip
    callback: set_threshp
    port: '6005'
    variable: threshp
  states: {}
- name: xmlrpc_client_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_f1
    port: '6005'
    variable: f1r
  states: {state: disabled}
- name: xmlrpc_server_1
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_1, '0', epy_block_2_0, '0']
- [blocks_throttle_3, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_number_sink_0, '0']
- [epy_block_2_0, '0', blocks_null_sink_0, '0']
- [epy_block_2_0, '0', qtgui_number_sink_1, '0']
- [fft_vxx_0_0_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [network_tcp_source_0, '0', blocks_throttle_3, '0']
- [network_tcp_source_1, '0', blocks_throttle_0, '0']
- [network_tcp_source_2_0, '0', blocks_stream_to_vector_0_1, '0']
- [network_tcp_source_2_0, '0', blocks_throttle_1, '0']
- [network_tcp_source_2_0_0, '0', qtgui_number_sink_0, '0']
- [network_tcp_source_2_0_0, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
